# Keil uVision project 沧海、&横流.uvprojx, settings and files
target Template_v1.8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 沧海、&横流 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\core;..\user\inc;..\groundwork\LED;..\library\STM32F4xx_StdPeriph_Driver\inc;..\modules;..\library\FreeRTOS\include;..\library\FreeRTOS\portable\MemMang;..\library\FreeRTOS\portable\RVDS\ARM_CM4F;..\library\SYSTEM\delay;..\library\SYSTEM\sys;..\library\SYSTEM\usart;..\algorithm;..\application;..\modules\OLED;..\groundwork\ADC;..\groundwork\SPI
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Freertos\core
    ../library/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS\portable
    ../library/FreeRTOS/portable/MemMang/: heap_4.c
    ../library/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group stdperiph_driver
    ../library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group core
    ../core/: startup_stm32f40_41xxx.s
  group system
    ../library/SYSTEM/sys/: sys.c
    ../library/SYSTEM/usart/: usart.c
    ../library/SYSTEM/delay/: delay.c
  group user
    ../user/src/: main.c stm32f4xx_it.c system_stm32f4xx.c start_task.c
  group groundwork
    ../groundwork/LED/: led.c
    ../groundwork/SPI/: bsp_spi.c
    ../groundwork/ADC/: bsp_adc.c
  group modules
    ../modules/OLED/: bsp_gui.c bsp_oled.c
  group readme
    ../: readme.txt
